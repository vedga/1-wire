# IAR project testPWM.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x6FF
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: __DRV_ONEWIRE_DMA=1; __DRV_ONEWIRE_ACTIVE_PULLUP
  ICCSTM8.CCIncludePath2: C:\Documents and Settings\monster\Мои документы\STM8\1wire\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/vos/drv/1wire/: drv_1wire.c
    ./: drv_clk.c main.c
    src/vos/kernel/stm8/: kernel.c
    src/vos/mod/1wire/: mod_1wire.c mod_1wire_search.c
